# IAR project spi_polling_slave_example.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: HPM6E50xGNx HPMicro HPM6E50xGNx
  General.GHeapSize: 0x4000
  ICCRISCV.IccLang: 2
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 2
  ICCRISCV.CCExtraOptions: --diag_suppress Pa089; --diag_suppress Pe236; --diag_suppress Pe188; --diag_suppress Pe546; --diag_suppress Pe111
  ICCRISCV.CCDefines: FLASH_XIP=1; HPMSOC_HAS_HPMSDK_MULTICORE=y; HPMSOC_HAS_HPMSDK_GPIO=y; HPMSOC_HAS_HPMSDK_PLIC=y; HPMSOC_HAS_HPMSDK_MCHTMR=y; HPMSOC_HAS_HPMSDK_PLICSW=y; HPMSOC_HAS_HPMSDK_GPTMR=y; HPMSOC_HAS_HPMSDK_UART=y; HPMSOC_HAS_HPMSDK_I2C=y; HPMSOC_HAS_HPMSDK_SPI=y; HPMSOC_HAS_HPMSDK_CRC=y; HPMSOC_HAS_HPMSDK_TSNS=y; HPMSOC_HAS_HPMSDK_MBX=y; HPMSOC_HAS_HPMSDK_EWDG=y; HPMSOC_HAS_HPMSDK_DMAMUX=y; HPMSOC_HAS_HPMSDK_DMAV2=y; HPMSOC_HAS_HPMSDK_PPI=y; HPMSOC_HAS_HPMSDK_GPIOM=y; HPMSOC_HAS_HPMSDK_LOBS=y; HPMSOC_HAS_HPMSDK_ADC16=y; HPMSOC_HAS_HPMSDK_ACMP=y; HPMSOC_HAS_HPMSDK_I2S=y; HPMSOC_HAS_HPMSDK_DAO=y; HPMSOC_HAS_HPMSDK_PDMLITE=y; HPMSOC_HAS_HPMSDK_MCAN=y; HPMSOC_HAS_HPMSDK_PTPC=y; HPMSOC_HAS_HPMSDK_QEIV2=y; HPMSOC_HAS_HPMSDK_QEOV2=y; HPMSOC_HAS_HPMSDK_PWMV2=y; HPMSOC_HAS_HPMSDK_RDC=y; HPMSOC_HAS_HPMSDK_SDM=y; HPMSOC_HAS_HPMSDK_PLB=y; HPMSOC_HAS_HPMSDK_SYNT=y; HPMSOC_HAS_HPMSDK_SEI=y; HPMSOC_HAS_HPMSDK_TRGM=y; HPMSOC_HAS_HPMSDK_MTG=y; HPMSOC_HAS_HPMSDK_VSC=y; HPMSOC_HAS_HPMSDK_CLC=y; HPMSOC_HAS_HPMSDK_ENET=y; HPMSOC_HAS_HPMSDK_USB=y; HPMSOC_HAS_HPMSDK_TSW=y; HPMSOC_HAS_HPMSDK_ESC=y; HPMSOC_HAS_HPMSDK_FEMC=y; HPMSOC_HAS_HPMSDK_FFA=y; HPMSOC_HAS_HPMSDK_SDP=y; HPMSOC_HAS_HPMSDK_PSEC=y; HPMSOC_HAS_HPMSDK_PMON=y; HPMSOC_HAS_HPMSDK_RNG=y; HPMSOC_HAS_HPMSDK_KEYM=y; HPMSOC_HAS_HPMSDK_OTP=y; HPMSOC_HAS_HPMSDK_SYSCTL=y; HPMSOC_HAS_HPMSDK_IOC=y; HPMSOC_HAS_HPMSDK_PLLCTLV2=y; HPMSOC_HAS_HPMSDK_PPOR=y; HPMSOC_HAS_HPMSDK_PCFG=y; HPMSOC_HAS_HPMSDK_PDGO=y; HPMSOC_HAS_HPMSDK_PGPR=y; HPMSOC_HAS_HPMSDK_BACC=y; HPMSOC_HAS_HPMSDK_BPOR=y; HPMSOC_HAS_HPMSDK_BCFG=y; HPMSOC_HAS_HPMSDK_BGPR=y; HPMSOC_HAS_HPMSDK_BSEC=y; HPMSOC_HAS_HPMSDK_RTC=y; HPMSOC_HAS_HPMSDK_BKEY=y; HPMSOC_HAS_HPMSDK_BMON=y; HPMSOC_HAS_HPMSDK_TAMP=y; HPMSOC_HAS_HPMSDK_MONO=y; HPMSOC_HAS_HPMSDK_PMP=y
  ICCRISCV.CCIncludePath2: ../../../sdk_env_v1.10.0/hpm_sdk/arch; ../../../sdk_env_v1.10.0/hpm_sdk/arch/riscv/l1c; ../../../sdk_env_v1.10.0/hpm_sdk/boards/hpm6e50board; ../../../sdk_env_v1.10.0/hpm_sdk/soc/HPM6E00/HPM6E80; ../../../sdk_env_v1.10.0/hpm_sdk/soc/HPM6E00/ip; ../../../sdk_env_v1.10.0/hpm_sdk/soc/HPM6E00/HPM6E80/toolchains; ../../../sdk_env_v1.10.0/hpm_sdk/soc/HPM6E00/HPM6E80/boot; ../../../sdk_env_v1.10.0/hpm_sdk/drivers/inc; ../../../sdk_env_v1.10.0/hpm_sdk/utils; ../../../sdk_env_v1.10.0/hpm_sdk/components/debug_console; ../build_tmp/generated/include
  IASMRISCV.AsmIncludePath: as above
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: demo.elf
  ILINK.IlinkConfigDefines: _flash_size=16M; _extram_size=32M
  ILINK.IlinkIcfFile: ..\..\..\sdk_env_v1.10.0\hpm_sdk\soc\HPM6E00\HPM6E80\toolchains\iar\flash_xip.icf
  ILINK.IlinkProgramEntryLabel: _start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCDefines: FLASH_XIP=1; HPMSOC_HAS_HPMSDK_MULTICORE=y; HPMSOC_HAS_HPMSDK_GPIO=y; HPMSOC_HAS_HPMSDK_PLIC=y; HPMSOC_HAS_HPMSDK_MCHTMR=y; HPMSOC_HAS_HPMSDK_PLICSW=y; HPMSOC_HAS_HPMSDK_GPTMR=y; HPMSOC_HAS_HPMSDK_UART=y; HPMSOC_HAS_HPMSDK_I2C=y; HPMSOC_HAS_HPMSDK_SPI=y; HPMSOC_HAS_HPMSDK_CRC=y; HPMSOC_HAS_HPMSDK_TSNS=y; HPMSOC_HAS_HPMSDK_MBX=y; HPMSOC_HAS_HPMSDK_EWDG=y; HPMSOC_HAS_HPMSDK_DMAMUX=y; HPMSOC_HAS_HPMSDK_DMAV2=y; HPMSOC_HAS_HPMSDK_PPI=y; HPMSOC_HAS_HPMSDK_GPIOM=y; HPMSOC_HAS_HPMSDK_LOBS=y; HPMSOC_HAS_HPMSDK_ADC16=y; HPMSOC_HAS_HPMSDK_ACMP=y; HPMSOC_HAS_HPMSDK_I2S=y; HPMSOC_HAS_HPMSDK_DAO=y; HPMSOC_HAS_HPMSDK_PDMLITE=y; HPMSOC_HAS_HPMSDK_MCAN=y; HPMSOC_HAS_HPMSDK_PTPC=y; HPMSOC_HAS_HPMSDK_QEIV2=y; HPMSOC_HAS_HPMSDK_QEOV2=y; HPMSOC_HAS_HPMSDK_PWMV2=y; HPMSOC_HAS_HPMSDK_RDC=y; HPMSOC_HAS_HPMSDK_SDM=y; HPMSOC_HAS_HPMSDK_PLB=y; HPMSOC_HAS_HPMSDK_SYNT=y; HPMSOC_HAS_HPMSDK_SEI=y; HPMSOC_HAS_HPMSDK_TRGM=y; HPMSOC_HAS_HPMSDK_MTG=y; HPMSOC_HAS_HPMSDK_VSC=y; HPMSOC_HAS_HPMSDK_CLC=y; HPMSOC_HAS_HPMSDK_ENET=y; HPMSOC_HAS_HPMSDK_USB=y; HPMSOC_HAS_HPMSDK_TSW=y; HPMSOC_HAS_HPMSDK_ESC=y; HPMSOC_HAS_HPMSDK_FEMC=y; HPMSOC_HAS_HPMSDK_FFA=y; HPMSOC_HAS_HPMSDK_SDP=y; HPMSOC_HAS_HPMSDK_PSEC=y; HPMSOC_HAS_HPMSDK_PMON=y; HPMSOC_HAS_HPMSDK_RNG=y; HPMSOC_HAS_HPMSDK_KEYM=y; HPMSOC_HAS_HPMSDK_OTP=y; HPMSOC_HAS_HPMSDK_SYSCTL=y; HPMSOC_HAS_HPMSDK_IOC=y; HPMSOC_HAS_HPMSDK_PLLCTLV2=y; HPMSOC_HAS_HPMSDK_PPOR=y; HPMSOC_HAS_HPMSDK_PCFG=y; HPMSOC_HAS_HPMSDK_PDGO=y; HPMSOC_HAS_HPMSDK_PGPR=y; HPMSOC_HAS_HPMSDK_BACC=y; HPMSOC_HAS_HPMSDK_BPOR=y; HPMSOC_HAS_HPMSDK_BCFG=y; HPMSOC_HAS_HPMSDK_BGPR=y; HPMSOC_HAS_HPMSDK_BSEC=y; HPMSOC_HAS_HPMSDK_RTC=y; HPMSOC_HAS_HPMSDK_BKEY=y; HPMSOC_HAS_HPMSDK_BMON=y; HPMSOC_HAS_HPMSDK_TAMP=y; HPMSOC_HAS_HPMSDK_MONO=y; HPMSOC_HAS_HPMSDK_PMP=y; NDEBUG
  group sdk_sample/drivers/spi/polling/slave/src
    ../../../sdk_env_v1.10.0/hpm_sdk/samples/drivers/spi/polling/slave/src/: spi.c
  group soc/HPM6E00/HPM6E80
    ../../../sdk_env_v1.10.0/hpm_sdk/soc/HPM6E00/HPM6E80/: system.c hpm_sysctl_drv.c hpm_clock_drv.c hpm_otp_drv.c hpm_trgm_soc_drv.c
  group soc/HPM6E00/HPM6E80/toolchains
    ../../../sdk_env_v1.10.0/hpm_sdk/soc/HPM6E00/HPM6E80/toolchains/: reset.c trap.c reset.c trap.c
  group soc/HPM6E00/HPM6E80/toolchains/iar
    ../../../sdk_env_v1.10.0/hpm_sdk/soc/HPM6E00/HPM6E80/toolchains/iar/: startup.s
  group soc/HPM6E00/HPM6E80/boot
    ../../../sdk_env_v1.10.0/hpm_sdk/soc/HPM6E00/HPM6E80/boot/: hpm_bootheader.c
  group arch/riscv/l1c
    ../../../sdk_env_v1.10.0/hpm_sdk/arch/riscv/l1c/: hpm_l1c_drv.c
  group boards/hpm6e50board
    ../../../sdk_env_v1.10.0/hpm_sdk/boards/hpm6e50board/: pinmux.c board.c
  group drivers/src
    ../../../sdk_env_v1.10.0/hpm_sdk/drivers/src/: hpm_uart_drv.c hpm_femc_drv.c hpm_sdp_drv.c hpm_i2c_drv.c hpm_pmp_drv.c hpm_mtg_drv.c hpm_rng_drv.c hpm_gpio_drv.c hpm_spi_drv.c hpm_gptmr_drv.c hpm_pwmv2_drv.c hpm_pllctlv2_drv.c hpm_usb_drv.c hpm_rtc_drv.c hpm_acmp_drv.c hpm_i2s_drv.c hpm_dao_drv.c hpm_pdmlite_drv.c hpm_enet_drv.c hpm_adc16_drv.c hpm_pcfg_drv.c hpm_ptpc_drv.c hpm_mchtmr_drv.c hpm_ffa_drv.c hpm_tsns_drv.c hpm_crc_drv.c hpm_sdm_drv.c hpm_mcan_drv.c hpm_qeiv2_drv.c hpm_enc_pos_drv.c hpm_sei_drv.c hpm_qeov2_drv.c hpm_rdc_drv.c hpm_dmav2_drv.c hpm_ewdg_drv.c hpm_plb_drv.c hpm_tamp_drv.c hpm_vsc_drv.c hpm_clc_drv.c hpm_esc_drv.c hpm_ppi_drv.c hpm_lobs_drv.c hpm_tsw_drv.c
  group utils
    ../../../sdk_env_v1.10.0/hpm_sdk/utils/: hpm_sbrk.c hpm_swap.c hpm_ffssi.c hpm_crc32.c
  group components/debug_console
    ../../../sdk_env_v1.10.0/hpm_sdk/components/debug_console/: hpm_debug_console.c
